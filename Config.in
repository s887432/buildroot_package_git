## Config.in
```kconfig
config BR2_PACKAGE_HELLOWORLD
	bool "helloworld demo"
	help
	  helloworld demo application.
```
